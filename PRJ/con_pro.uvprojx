# Keil uVision project con_pro.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: con_pro +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\PRJ_OUT\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\DEVICE_CORE;..\DEVICE_LIB\Inc;..\DEVICE_BSP;..\USR_FUNC;..\USR_APP;..\USR_MAIN
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group DEVICE_CORE
    ../DEVICE_CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group DEVICE_LIB
    ../DEVICE_LIB/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group DEVICE_BSP
    ../DEVICE_BSP/: bsp_sysclock_config.c bsp_crc.c bsp_iwdg.c bsp_systick.c bsp_flash.c bsp_dma.c bsp_exti.c bsp_in_io.c bsp_out_io.c bsp_timer.c bsp_led.c bsp_uart.c bsp_spi.c bsp_beep.c bsp_key.c bsp_hard_oled.c bsp_soft_oled.c bsp_dht11_io.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group USR_FUNC
    ../USR_FUNC/: func_s_state_machine.c func_s_ring_queue.c func_s_string_process.c func_s_data_flow_process.c func_s_version_con.c func_s_crc16.c func_s_crc8.c func_s_xorc8.c func_s_delay.c func_time_mark.c func_beep.c func_alone_key.c func_oled.c func_ir_decode.c func_ir_nec_key.c func_dht11.c func_pc_interface_com.c
  group USR_APP
    ../USR_APP/: app_oled_display.c
  group USR_MAIN
    ../USR_MAIN/: main.c
